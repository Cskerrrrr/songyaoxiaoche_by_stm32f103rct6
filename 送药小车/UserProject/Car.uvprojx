# Keil uVision project Car.uvprojx, settings and files
target 电赛3轮车 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\UserProject;..\STM32F10x_Lib\inc;..\Core;..\HDR\ENCODER;..\HDR\MOTOR;..\HDR\PWM;..\HDR\USART2;..\system;..\HDR;.\Listings;..\HDR\PID;..\HDR\HC-SR04;..\HDR\xunji;..\HDR\EXTI;..\HDR\MPU6050;..\HDR\MPU6050\eMPL;..\HDR\timer;..\UserProject;..\HDR\LCD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c GUI.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HDR
    ../HDR/ENCODER/: encoder.c
    ../HDR/MOTOR/: motor.c
    ../HDR/USART2/: usart2.c
    ../HDR/PID/: pid.c
    ../HDR/HC-SR04/: SR04.c
    ../HDR/xunji/: xunji.c
    ../HDR/EXTI/: exti.c
    ../HDR/MPU6050/: mpu6050.c mpuiic.c
    ../HDR/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HDR/LCD/: lcd.c
  group system
    ../system/: delay.c sys.c usart.c
